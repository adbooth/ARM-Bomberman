# Keil uVision project lab7.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: lab7
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: lab7cwrapper.c general_library.s graphics_library.s hardware_library.s lab7.s Startup.s string_library.s
